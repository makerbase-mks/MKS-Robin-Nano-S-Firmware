<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>mksRobin2</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f407xx.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <group>
        <name>QRENCODE</name>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\bitstream.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\mask.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\mmask.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\mqrspec.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\QR_Encode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\qrencode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\qrinput.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\qrspec.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\rscode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\QRENCODE\split.c</name>
        </file>
      </group>
      <group>
        <name>UI</name>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_about.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_acceleration.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_advanced.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_babyStep.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_bind.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_change_speed.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_deltaLevelPare.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_dialog.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_disk.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_doubleZ.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_EnablePin_Invert.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_endstop_type.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_extrusion.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_fan.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_filament_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_filamentchange.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_FileTransfer_ui.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_gcode_command.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_home_dir.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_home_speed.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_hotbed_config.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_jerk.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_keyboard.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_language.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_leveling_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_levelingPara_config.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_machine_para.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_machine_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_machine_type.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_manual_leveling.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_MaxFeedRate.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_mesh_leveling.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_more.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_motor_dir.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_motor_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_move_motor.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_nozzle_config.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_number_key.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_operate.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_pause_ui.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_PausePos.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_pre_heat.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_print_file.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_printing.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_printing_moremenu.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_ready_print.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_set.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_steps.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_stroke.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_temperature_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_Tips.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_tool.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_ui.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_wifi.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_wifi_list.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_XYZLevelPara.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_zero.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\Multi_language\Font24_MS.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\Multi_language\fontHz14.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\Multi_language\Helvetica26.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\Multi_language\Helvetica36.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\id_manage.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\mks_fontHz14.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\Multi_language\multi_language.cpp</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Src\adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\bsp_driver_sd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\fatfs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\ili9320.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\mks_cfg.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\mks_test.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\mks_touch_screen.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\pic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\pic_manager.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_it.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\string_deal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\wifi_module.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\wifi_upload.cpp</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>BSP</name>
      <group>
        <name>Components</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\Components\at24cxx\at24cxx.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\Components\w25qxx\spi_flash.c</name>
        </file>
      </group>
      <group>
        <name>variant</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\variant\mks_variant.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>libstmf4</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\stm32f4xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\stm32f4xx_usart.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dac_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_hcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_sd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_sram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_sdmmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_usb.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Middlewares</name>
    <group>
      <name>Arduino</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\arduino\stm32\cores\arduino\Print.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\arduino\stm32\cores\arduino\RingBuffer.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\arduino\stm32\cores\arduino\Stream.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\arduino\stm32\cores\arduino\USARTClass.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\arduino\stm32\cores\arduino\WMath.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\arduino\stm32\cores\arduino\WString.cpp</name>
      </file>
    </group>
    <group>
      <name>FatFs</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\ff.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\ff_gen_drv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\option\mycc936.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\drivers\sd_diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\option\syscall.c</name>
      </file>
    </group>
    <group>
      <name>Marlin</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\blinkm.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\cardreader.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\configuration_store.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\dac_mcp4728.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\digipot_mcp4451.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\endstops.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\G26_Mesh_Validation_Tool.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\gcode.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\hex_print_routines.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\least_squares_fit.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\M100_Free_Mem_Chk.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\Marlin_main.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\MarlinSerial.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\mesh_bed_leveling.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\planner.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\planner_bezier.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\printcounter.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\serial.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\servo.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\stepper.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\stepper_dac.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\stepper_indirection.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\stopwatch.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\temperature.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\twibus.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\ubl.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\ubl_G29.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\ubl_motion.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\utility.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\vector_3.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\Marlin\watchdog.cpp</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Middlewares\GUI\GUI.a</name>
    </file>
  </group>
</project>


