<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\mksRobin2.ewp</path>
  </project>
  <batchBuild />
</workspace>
